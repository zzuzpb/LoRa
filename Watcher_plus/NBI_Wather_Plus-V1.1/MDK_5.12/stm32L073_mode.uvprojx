# Keil uVision project stm32L073_mode.uvprojx, settings and files
target STM32L0_MODE (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PRO_PLUS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx,USE_MODEM_LORA,USE_BAND_433,USING_RS485
  c misc: --C99
  c include: ..\CMSIS\Device\ST\STM32L0xx\Include;..\CMSIS\Include;..\stm32L0xx_HAL\Inc\Legacy;..\stm32L0xx_HAL\Inc;..\USER;..\HAL\sensor\inc;..\HAL\system;..\HAL\inc;..\Lib\LoRawan-node\misc;..\Lib\LoRawan-node\radio;..\Lib\LoRawan-node\radio\sx1276;..\Lib\LoRawan-node\mac;..\Lib\LoRawan-node\crypto;..\Lib;..\contiki-3.0\cpu\arm\stm32f103;..\contiki-3.0\core\sys;..\contiki-3.0\core;..\contiki-3.0\cpu\stm32w108
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l073xx.s
    ../CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group stm32L0xx_HAL
    ../stm32L0xx_HAL/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group HAL\src
    ../HAL/src/: usart.c spi.c rtc-board.c delay.c timer-board.c sx1276-board.c gpio-board.c adc.c timerserver.c iwdg.c i2c.c power.c user_bq24195.c bq24195.c user_battery.c
  group HAL\system
    ../HAL/system/: board.c gpio.c stmflash.c
  group HAL\sensor\src
    ../HAL/sensor/src/: gps.c FIFO_Uart.c flash.c minmea.c NBI_rs485.c user_mian.c
  group Lib\LoRawan-node
    ../Lib/LoRawan-node/radio/sx1276/: sx1276.c
    ../Lib/LoRawan-node/mac/: LoRaMac.c LoRaMac-api-v3.c LoRaMacCrypto.c
    ../Lib/LoRawan-node/misc/: utilities.c
    ../Lib/LoRawan-node/crypto/: aes.c cmac.c
  group Contiki_Sys
    ../contiki-3.0/core/sys/: autostart.c process.c timer.c etimer.c stimer.c rtimer-arch.c rtimer.c
  group Contiki_Clock
    ../contiki-3.0/cpu/arm/stm32f103/: clock.c
  group USER
    ../USER/: main.c stm32l0xx_it.c user-app.c LoRa-cad.c
  group TEST
    ../TEST/: rtc_main.c test_lora_pingpong.c
  group DOC
    ../DOC/: readme.txt
