# Keil uVision project NB_LoRaGateway.uvprojx, settings and files
target NB_LoRaGateway (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: NB_LoRaGateway +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_MODEM_LORA,USE_BAND_433
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include;..\Lib\LoRawan-node;..\Lib\LoRawan-node\crypto;..\Lib\LoRawan-node\mac;..\Lib\LoRawan-node\misc;..\Lib\LoRawan-node\radio\sx1276;..\Lib\LoRawan-node\radio;..\Lib\Ethernet\Internet;..\Lib\Ethernet\W5500;..\HAL\inc;..\HAL\system;..\contiki-3.0\core;..\contiki-3.0\core\sys;..\contiki-3.0\cpu\arm\stm32f103
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_cortex.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc.c stm32f2xx_hal_tim.c stm32f2xx_hal_uart.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_gpio.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Application/User
    ../Src/: main.c stm32f2xx_hal_msp.c tim.c usart.c gpio.c stm32f2xx_it.c spi.c LoRa-cad.c user-app.c dma.c sim7600.c
  group Lib/LoRawan-node
    ../Lib/LoRawan-node/crypto/: aes.c cmac.c
    ../Lib/LoRawan-node/mac/: LoRaMac.c LoRaMac-api-v3.c LoRaMacCrypto.c
    ../Lib/LoRawan-node/misc/: utilities.c
    ../Lib/LoRawan-node/radio/sx1276/: sx1276.c
  group Lib/Ethernet/Internet
    ../Lib/Ethernet/Internet/: dhcp.c tcp_demo.c
  group Lib/Ethernet/W5500
    ../Lib/Ethernet/W5500/: socket.c utility.c w5500.c w5500_conf.c
  group HAL/src
    ../HAL/src/: delay.c gpio-board.c sx1276-board.c timer-board.c timerserver.c
  group HAL/system
    ../HAL/system/: board.c stmflash.c
  group DOC
    ../DOC/: readme.txt
  group Contiki_sys
    ../contiki-3.0/core/sys/: autostart.c timer.c process.c stimer.c etimer.c
  group Contiki_clock
    ../contiki-3.0/cpu/arm/stm32f103/: clock.c
software components: CMSIS:CORE 4.1.0
