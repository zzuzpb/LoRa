# Keil uVision project stm32f030cc.uvprojx, settings and files
target stm32f0300c_LoRaWAN (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LoRawan +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030xC,USE_MODEM_LORA,USE_BAND_433
  c misc: --C99
  c include: ..\CMSIS\Device\ST\STM32F0xx\Include;..\CMSIS\Include;..\stm32f03xx_HAL\Inc;..\USER;..\HAL\inc;..\HAL\system;..\Lib\LoRawan-node\misc;..\Lib\LoRawan-node\crypto;..\Lib\LoRawan-node\mac;..\Lib\LoRawan-node\radio;..\Lib\LoRawan-node\radio\sx1276;..\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030xc.s
  group STM32F0xx_HAL
    ../stm32f03xx_HAL/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_crc.c stm32f0xx_ll_crs.c stm32f0xx_ll_dac.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_rtc.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
  group HAL\src
    ../HAL/src/: usart.c rtc-board.c timer.c timer-board.c delay.c spi.c gpio-board.c sx1276-board.c control.c flash.c hexbin_decoct.c
  group HAL\system
    ../HAL/system/: board.c gpio.c
  group Lib\LoRawan-node
    ../Lib/LoRawan-node/misc/: utilities.c
    ../Lib/LoRawan-node/crypto/: aes.c cmac.c
    ../Lib/LoRawan-node/mac/: LoRaMac.c LoRaMac-api-v3.c LoRaMacCrypto.c
    ../Lib/LoRawan-node/radio/sx1276/: sx1276.c
  group USER
    ../USER/: main.c stm32f0xx_it.c user-app.c LoRa-cad.c
  group TEST
    ../TEST/: test_lora_pingpong.c rtc_main.c
  group DOC
    ../DOC/: readme.txt
