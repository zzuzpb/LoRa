# Keil uVision project NBI_Watcher_Pro2_v1.0.uvprojx, settings and files
target NBI_Watcher_Pro2_v1.0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L072CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Mini_v00 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx
  c include: ../Inc;  ../Drivers/STM32L0xx_HAL_Driver/Inc;  ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;  ../Drivers/CMSIS/Include;  ..\USER\include
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Application/User
    ../Src/: stm32l0xx_it.c stm32l0xx_hal_msp.c main.c
  group USER
    ../USER/source/: user_main.c user_sensor_pro2.c user_server.c user_sim.c user_spi_flash.c user_led.c user_gps.c user_flash_L072.c user_battery.c user_adc.c
    ../USER/include/: bootloader_config.h
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_rtc.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_tim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_adc.c
software components: CMSIS:CORE 4.3.0
